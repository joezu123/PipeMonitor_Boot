# IAR project Pipe_Monitor_BootLoadre_Ymodem.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../../../../../../midwares/hc32/iap/ymodem; ..\drv_device\4G_EC200U; ..\drv_device\W25Q128
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Pipe_Monitor_BootLoadre_Ymodem.bin
  ILINK.IlinkOutputFile: iap_ymodem_boot.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F460_512K_= 1
  ILINK.IlinkIcfFile: config\linker\HC32F460.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../../../../../../midwares/hc32/iap/ymodem
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: iap_ymodem_boot.hex
  ILINK.IlinkIcfFile: config/linker/HC32F460.icf
  group (top)
    ../: Readme.txt
  group cmsis
    ./: startup_hc32f460.s
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c
  group driver/drv_device/4G_EC200U
    ../drv_device/4G_EC200U/: 4G_EC200U.c
  group driver/drv_device/W25Q128
    ../drv_device/W25Q128/: W25Q128.c
  group midwares/iap/ymodem
    ../../../../../../midwares/hc32/iap/ymodem/: ymodem.c
  group source
    ../source/: com.c Display.c flash.c Font.c main.c OLED.c
